Commit message: Defend and Attack State

File: Airhockey/model/panda/panda_arm.urdf (robot description, URDF)
Before this commit: robot panda, 8 links, 7 joints
Links:
- link link7: geometry collision cylinder length=0.07 radius=0.055; visual mesh filename=meshes/visual/link7.obj
